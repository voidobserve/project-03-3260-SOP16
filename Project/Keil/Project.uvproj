# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: Demo +hex
  AfterMake: .\make.bat
  c flags: Optimize=8 SizeSpeed=1
  c misc: interval(3)
  c include: ..\..\Libraries\Include;..\..\User;..\..\User\lib
  asm include: ..\..\Libraries;..\..\Libraries\C51
  group Startup
    ../../Libraries/Startup/: STARTUP.A51
    ../../Libraries/Source/: system.c
  group User
    ../../User/lib/: tk_config.h tk_debug.c tk_set.c
    ../../User/: main.c tk_user.c my_gpio.c send_key.c flash.c rf_learn.c rf_recv.c tmr3.c rf_scan.c tmr2.c key_conversion.c my_config.h tmr4.c
  group LIb
    ../../User/lib/: tk_simplify_algorithm_V1.0.0.LIB
